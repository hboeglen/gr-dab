options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dab_transmitter
    output_language: python
  states: {}

blocks:
- name: ampl
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: int
    value: '201072000'
  states: {}
- name: gain_range
  id: variable_qtgui_range
  parameters:
    label: Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '384'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1] + [0]*74'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/herve/Documents/Adé - Tout savoir.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: dab_dab_transmission_frame_mux_bb_0
  id: dab_dab_transmission_frame_mux_bb
  parameters:
    dab_mode: '1'
    num_subch: '1'
    subch_size: '[66]'
  states: {}
- name: dab_fib_source_b_0
  id: dab_fib_source_b
  parameters:
    coutry_ID: '1'
    dabplus: '[1]'
    data_rate_n: '[11]'
    ensemble_label: '"GNU Radio Tune"'
    num_subch: '1'
    programme_service_labels: '"DABstep         "'
    protection_mode: '[2]'
    service_comp_lang: '1'
    transmission_mode: '1'
  states: {}
- name: dab_fic_encode_0
  id: dab_fic_encode
  parameters:
    dab_mode: '1'
    samp_rate: samp_rate
  states: {}
- name: dab_mp4_encode_sb_0
  id: dab_mp4_encode_sb
  parameters:
    afterburner: '0'
    bit_rate_n: '11'
    channels: '2'
    samp_rate: '48000'
  states: {}
- name: dab_msc_encode_0
  id: dab_msc_encode
  parameters:
    dab_mode: '1'
    data_rate_n: '11'
    protection: '2'
    samp_rate: samp_rate
  states: {}
- name: dab_ofdm_mod_0
  id: dab_ofdm_mod
  parameters:
    dab_mode: '1'
    samp_rate: samp_rate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate*8
    type: fc32
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      1. Set frequency and clock source (default is external clock for better performance of the transmitter) in USRP
      2. Choose audio source (.wav file or audio source)
      3. Add more sub channels (optional)
      4. Write Service Info and Multiplex Info in FIB source

      Execute "DABstep" out of your terminal for a more user-friendly graphical application
    note: 'Instructions:'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: reed_solomon_encode_bb_0
  id: reed_solomon_encode_bb
  parameters:
    bit_rate_n: '11'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(freq, 2*samp_rate)
    clock_rate: int(8*samp_rate)
    dev_args: '""'
    gain0: gain_range
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(freq, 2*samp_rate)
    dev_args: '""'
    gain0: '50'
    len_tag_name: ''
    samp_rate: samp_rate*8
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_float_to_short_0, '0', dab_mp4_encode_sb_0, '0']
- [blocks_float_to_short_0_0, '0', dab_mp4_encode_sb_0, '1']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_1, '0']
- [blocks_stream_to_vector_0, '0', dab_ofdm_mod_0, '0']
- [blocks_vector_source_x_0, '0', dab_ofdm_mod_0, '1']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '1', audio_sink_0, '1']
- [blocks_wavfile_source_0, '1', blocks_float_to_short_0_0, '0']
- [dab_dab_transmission_frame_mux_bb_0, '0', blocks_stream_to_vector_0, '0']
- [dab_fib_source_b_0, '0', dab_fic_encode_0, '0']
- [dab_fic_encode_0, '0', dab_dab_transmission_frame_mux_bb_0, '0']
- [dab_mp4_encode_sb_0, '0', reed_solomon_encode_bb_0, '0']
- [dab_msc_encode_0, '0', dab_dab_transmission_frame_mux_bb_0, '1']
- [dab_ofdm_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [reed_solomon_encode_bb_0, '0', dab_msc_encode_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
