options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dab_receiver
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: int
    value: '178352000'
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '40'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2048/30
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: dab_dabplus_audio_decoder_ff_1
  id: dab_dabplus_audio_decoder_ff
  parameters:
    address: '0'
    bit_rate: '64'
    dab_mode: '1'
    output_float: 'True'
    protection: '0'
    samp_rate: samp_rate
    subch_size: '96'
  states: {}
- name: dab_fic_decode_vc_0
  id: dab_fic_decode_vc
  parameters:
    dab_mode: '1'
    samp_rate: samp_rate
  states: {}
- name: dab_ofdm_demod_cc_0
  id: dab_ofdm_demod_cc
  parameters:
    dab_mode: '1'
    samp_rate: samp_rate
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      1. Enable the data source of your choice and set the center frequency for hardware devices
      2. Run flowgraph and  adjust gain
      3. Read fib_sink info in the console to get the DAB Decoder info
      4. Set the DAB+ Decoder info and restart flowgraph

      Execute "DABstep" out of your terminal for a more user-friendly graphical application
    note: 'Instructions:'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: '10'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: gain_slider
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: 8*samp_rate
    dev_args: '""'
    gain0: gain_slider
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [dab_dabplus_audio_decoder_ff_1, '0', audio_sink_0, '0']
- [dab_dabplus_audio_decoder_ff_1, '1', audio_sink_0, '1']
- [dab_ofdm_demod_cc_0, '0', blocks_vector_to_stream_0, '0']
- [dab_ofdm_demod_cc_0, '0', dab_fic_decode_vc_0, '0']
- [dab_ofdm_demod_cc_0, '1', dab_dabplus_audio_decoder_ff_1, '0']
- [rtlsdr_source_0, '0', dab_ofdm_demod_cc_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', dab_ofdm_demod_cc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
